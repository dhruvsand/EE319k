# Keil uVision project Exam2.uvproj, settings and files
target Exam2 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Exam2
  c flags: Optim=1
  c misc: --C99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source code
    ./: Startup.s Exam2AsmPart.s Exam2CPart.c
  group Object code
    ./: uart.o pll.o main.o

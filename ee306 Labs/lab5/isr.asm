	.ORIG x1500
	
	ST R0, SAVER0
	
	ST R2, SAVER2
	ST R3, SAVER3
	ST R4, SAVER4
	ST R5, SAVER5
	ST R6, SAVER6
	ST R7, SAVER7

	LD  R0,NEWLINE
	OUT
	GETC
	OUT
	LEA R0,START
	PUTS


	ADD R1,R1,#1
	AND R2,R2,#0
	ADD R2,R2,R1

	LD R3,ONEDIGIT
	AND R0,R0,#0
	
LOOP1
	ADD R0,R0,#1
	ADD R2,R2,R3
	BRP LOOP1

	ADD R0,R0,#-1
	JSR NUMBERPRINTER
	NOT R3,R3
	ADD R3,R3,#1
	ADD R2,R2,R3


LD R3,TWODIGIT
	AND R0,R0,#0
	
LOOP2
	ADD R0,R0,#1
	ADD R2,R2,R3
	BRP LOOP2

	ADD R0,R0,#-1
	JSR NUMBERPRINTER
	NOT R3,R3
	ADD R3,R3,#1
	ADD R2,R2,R3



LD R3,THREEDIGIT
	AND R0,R0,#0
	
LOOP3
	ADD R0,R0,#1
	ADD R2,R2,R3
	BRP LOOP3

	ADD R0,R0,#-1
	JSR NUMBERPRINTER
	NOT R3,R3
	ADD R3,R3,#1
	ADD R2,R2,R3

LD R3,FOURDIGIT
	AND R0,R0,#0
	
LOOP4
	ADD R0,R0,#1
	ADD R2,R2,R3
	BRP LOOP4

	ADD R0,R0,#-1
	JSR NUMBERPRINTER
	

		















	LEA R0,END
	PUTS
	LD  R0,NEWLINE
	OUT

	LD R0, SAVER0
	
	LD R2, SAVER2
	LD R3, SAVER3
	LD R4, SAVER4
	LD R5, SAVER5
	LD R6, SAVER6
	LD R7, SAVER7



	RTI



ONEDIGIT .FILL X-1000
TWODIGIT .FILL X-0100
THREEDIGIT .FILL X-0010
FOURDIGIT  .FILL X-0001


SAVER0	.BLKW 1
SAVER1	.BLKW 1
SAVER2	.BLKW 1
SAVER3	.BLKW 1
SAVER4	.BLKW 1
SAVER5	.BLKW 1
SAVER6	.BLKW 1
SAVER7	.BLKW 1

KBDR	.FILL XFE02
NEWLINE	.FILL X000A
START 	.STRINGZ " (x"
END	.STRINGZ ")"



















NUMBERPRINTER
	ST R2, SAVER22
	ST R3, SAVER32
	ST R4, SAVER42
	ST R5, SAVER52
	ST R6, SAVER62
	ST R7, SAVER72

	AND R2,R2,#0
	ADD R2,R2,R0
	ADD R2,R2,#-9
	BRP LETTEROUTPUT

	LD R3,NUMBER
	ADD R0,R0,R3
	OUT
	BR LAST

LETTEROUTPUT
	LD R3,LETTER
	ADD R0,R2,R3
	OUT
	
	

LAST	LD R2, SAVER22
	LD R3, SAVER32
	LD R4, SAVER42
	LD R5, SAVER52
	LD R6, SAVER62
	LD R7, SAVER72

	RET






NUMBER	.FILL X0030
LETTER .FILL X0040
SAVER22	.BLKW 1
SAVER32	.BLKW 1
SAVER42	.BLKW 1
SAVER52	.BLKW 1
SAVER62	.BLKW 1
SAVER72	.BLKW 1


	.END

